# Keil uVision project stc8g2k64s4.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc8g2k64s4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c ADC.c delay.c timer.c UART.C Exti.c GPIO.c
